do_deploy:append(){
    echo "dtoverlays=uart0-pi5" >>$CONFIG
}