COMPATIBLE_MACHINE = "raspberrypi4|raspberrypi4-64|raspberrypi5_custom"
